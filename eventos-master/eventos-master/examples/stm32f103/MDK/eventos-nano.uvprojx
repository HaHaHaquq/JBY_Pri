# Keil uVision project eventos-nano.uvprojx, settings and files
target EventOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: eventos-nano
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,
  c include: ..\APP;..\MCU;..\..\..\eventos;..\..\..\3rd
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c port_stm32f103.c eos_led_reactor.c eos_led_sm.c
  group MCU
    ../MCU/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group EventOS
    ../../../eventos/: eventos.c
  group 3rd
    ../../../3rd/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
